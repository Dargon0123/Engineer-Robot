# Keil uVision project SeekFree_Kinetis.uvprojx, settings and files
target SeekFree_MK60DN10 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MK60DN512xxx10 Freescale
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: SeekFree_Kinetis
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\USER\inc;..\USER\src;..\..\Libraries\startup\CoreSupport;..\..\Libraries\startup\DeviceSupport\MDK-ARM;..\..\Libraries\startup\DeviceSupport;..\..\Libraries\drives\inc;..\..\Libraries\drives\src;..\..\Libraries\seekfree;..\..\Libraries\FatFs;..\..\Libraries\FatFs\option
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group startup
    ../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK60D10.s
    ../../Libraries/startup/DeviceSupport/: system_MK60D10.c
  group drives_h
    ../../Libraries/drives/inc/: MK60DN10_sdhc.h MK60DN10_cmt.h misc.h common.h MK60DN10_port_cfg.h MK60DN10_gpio.h MK60DN10_port.h MK60DN10_systick.h MK60DN10_uart.h MK60DN10_pit.h MK60DN10_lptmr.h MK60DN10_ftm.h MK60DN10_adc.h MK60DN10_dac.h MK60DN10_dma.h MK60DN10_flash.h MK60DN10_spi.h MK60DN10_wdog.h MK60DN10_rtc.h MK60DN10_i2c.h
  group drives_c
    ../../Libraries/drives/src/: misc.c common.c MK60DN10_gpio.c MK60DN10_port.c MK60DN10_systick.c MK60DN10_uart.c MK60DN10_pit.c MK60DN10_lptmr.c MK60DN10_ftm.c MK60DN10_adc.c MK60DN10_dac.c MK60DN10_dma.c MK60DN10_flash.c MK60DN10_spi.c MK60DN10_wdog.c MK60DN10_rtc.c MK60DN10_i2c.c MK60DN10_cmt.c MK60DN10_sdhc.c
  group user_h
    ../USER/inc/: isr.h
    ../../Libraries/drives/inc/: headfile.h
  group user_c
    ../USER/src/: isr.c main.c
    ../../Libraries/: version.txt
  group seekfree
    ../../Libraries/seekfree/: SEEKFREE_18TFT.c SEEKFREE_18TFT.h SEEKFREE_7725.c SEEKFREE_7725.h SEEKFREE_FUN.c SEEKFREE_FUN.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_L3G4200D.c SEEKFREE_L3G4200D.h SEEKFREE_MMA8451.c SEEKFREE_MMA8451.h SEEKFREE_MPU6050.c SEEKFREE_MPU6050.h SEEKFREE_MT9V032.c SEEKFREE_MT9V032.h SEEKFREE_NRF24L01.c SEEKFREE_NRF24L01.h SEEKFREE_OLED.c SEEKFREE_OLED.h SEEKFREE_TSL1401.c SEEKFREE_TSL1401.h font.c font.h
  group fatfs
    ../../Libraries/FatFs/: 00readme.txt diskio.c diskio.h ff.c ff.h ffconf.h integer.h
